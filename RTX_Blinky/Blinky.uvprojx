# Keil uVision project Blinky.uvprojx, settings and files
target STM32F030 Flash (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: Blinky.c LED.c
  group Documentation
    ./: Abstract.txt
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.3/CMSIS_RTX/Lib/ARM/: RTX_CM0.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/STM32F030R8/: startup_stm32f030x8.s system_stm32f0xx.c
target STM32F030 RAM (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1920
  memory RVCT9: RAM 0x20001920 size 0x6e0
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.73.0, Device:Startup 1.0.0
